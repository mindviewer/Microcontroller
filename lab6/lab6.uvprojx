# Keil uVision project lab6.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: M487SIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.22
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: lab6
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\MPD_M480\House_ware;.\MPD_M480\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group User
    ./: main.c
  group Source
    ./MPD_M480/M480_source/: clk.c eadc.c ebi.c fmc.c gpio.c GUI_X.c GUIConf.c i2c.c LCDConf.c myGUI.c myGUI.h NUemWin_CM4_Keil.lib sdh.c sys.c timer.c uart.c
  group House_ware
    ./MPD_M480/House_ware/: ADCAgent.c ADCAgent.h BNCTL.c BNCTL.h display.c display.h I2C_EEPROM.c I2C_EEPROM.h StepMotorAgent.c StepMotorAgent.h system_init.c system_init.h TempSensor.c TempSensor.h tmr.c tmr.h UART1.c UART1.h
software components: CMSIS:CORE 5.4.0, Device:Startup 0.00.001

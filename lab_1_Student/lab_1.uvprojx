# Keil uVision project lab_1.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.22
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: lab_1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\MPD_M480\House_ware;.\MPD_M480\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group User
    ./: main.c
  group Source
    ./MPD_M480/M480_source/: clk.c
    ../../../lab_1/MPD_M480/M480_source/: gpio.c
software components: CMSIS:CORE 5.3.0, Device:Startup 0.00.001
